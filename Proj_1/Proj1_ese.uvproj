# Keil uVision project Proj1_ese.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: Proj1_ese
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Proj1_main.c
